## code/drivers/gy61/Kconfig
```kconfig
# A little chip that tells you where gravity is

menuconfig GY61
    bool "ADXL355 GY61 3-axis accelerometer"
    depends on ADC
```
